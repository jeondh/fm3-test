# IAR project mb9bf506r_qprc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF506R Fujitsu MB9BF506R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\common; ..\source; ..\..\..\driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb9bf506r_qprc.srec
  ILINK.IlinkOutputFile: mb9bf506r_qprc.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group common
    ../../../common/: system_mb9bf50x.c
  group driver
    ../../../driver/qprc/: qprc_fm3.c
  group source_files
    ../source/: main.c
    ./: startup_mb9bf50x.s
