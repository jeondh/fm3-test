# IAR project mb9bf506r_mfs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF506R Fujitsu MB9BF506R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: mb9bf506r_mfs.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Common
    ../../../common/: system_mb9bf50x.c
  group PreLib
    ../../../driver/mfs/: mfs_fm3.c
  group PreLib/CSIO
    ../../../driver/mfs/csio/: csio_fm3.c
  group PreLib/UART
    ../../../driver/mfs/uart/: uart_fm3.c
  group Source
    ../source/: main.c sample_csio.c sample_uart.c
    ./: startup_mb9bf50x.s
