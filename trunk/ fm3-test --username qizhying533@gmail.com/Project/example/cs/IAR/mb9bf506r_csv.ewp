# IAR project mb9bf506r_csv.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF506R Fujitsu MB9BF506R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: PRINTF_DEBUG
  ICCARM.CCIncludePath2: ..\source; ..\..\..\common; ..\..\..\driver; ..\..\..\driver\clock
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb9bf506r_csv.srec
  ILINK.IlinkOutputFile: mb9bf506r_csv.out
  ILINK.IlinkIcfFile: config\mb9bf506.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\common; ..\..\example\source
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: mb9bf506r_template.srec
  ILINK.IlinkOutputFile: mb9bf506r_template.out
  group common
    ../../../common/: system_mb9bf50x.c
  group library
    ../../../driver/cs/: csv_fm3.c
  group example
    ../source/: main.c
    ./: startup_mb9bf50x.s
