# IAR project Backup of mb9bf506r_wd_soft.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF506R Fujitsu MB9BF506R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\..\common; ..\..\..\..\driver; ..\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: mb9bf506r_wd_soft.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Common
    ../../../../common/: system_mb9bf50x.c
  group PreLib
    ../../../../driver/wd/: wd_fm3.c
  group Source
    ../Source/: main.c
  group Startup
    ./: startup_mb9bf50x.s
