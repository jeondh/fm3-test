# IAR project mb9bf506r_wc_subclk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF506R Fujitsu MB9BF506R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\common; ..\..\..\..\driver; ..\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: mb9bf506r_wc_subclk.out
  ILINK.IlinkIcfFile: config\mb9bf506.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Common
    ../../../../common/: system_mb9bf50x.c
  group Peripheral Lib
    ../../../../driver/wc/: wc_fm3.c
  group Source
    ../source/: main.c
  group Startup
    ./: startup_mb9bf50x.s
