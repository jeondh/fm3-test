# IAR project mb9bf506r_usbf_hid_mouse.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF506R Fujitsu MB9BF506R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: KSK_MB9BF506
  ICCARM.CCIncludePath2: ..\..\..\..\common; ..\..\..\..\driver; ..\..\..\..\driver\usbf; ..\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: mb9bf506r_usbf_hid_mouse.out
  ILINK.IlinkIcfFile: config\mb9bf506.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../source/: buttons.c hid_mouse.c main.c usb_dev_desc.c usb_hooks.c
  group Common
    ../../../../common/: system_mb9bf50x.c
  group Startup
    ./: startup_mb9bf50x.s
  group USBFLib
    ../../../../driver/usbf/: usb_core_fm3.c usb_dma_fm3.c usb_hw_fm3.c
