# IAR project mb9bf506r_dmac.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF506R Fujitsu MB9BF506R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\common; ..\..\..\driver; ..\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb9bf506r_dmac.srec
  ILINK.IlinkOutputFile: mb9bf506r_dmac.out
  ILINK.IlinkIcfFile: config\mb9bf506.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group common
    ../../../common/: system_mb9bf50x.c
  group driver
    ../../../driver/dmac/: dmac_fm3.c
  group source
    ../source/: sample_main.c
    ./: startup_mb9bf50x.s
