# IAR project mb9bf506r_template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF506R Fujitsu MB9BF506R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\common; ..\source; ..\..\..\..\driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb9bf506r_template.srec
  ILINK.IlinkOutputFile: mb9bf506r_template.out
  ILINK.IlinkIcfFile: config\mb9bf506_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\common; ..\..\example\source
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: Readme.txt
  group common
    ../../../../common/: system_mb9bf50x.c
  group source_files
    ../source/: debug.h main.c mb9bf50x_int.c mb9bf50x_lib.h mcu.h TEST_MFT_ADCMP.c TEST_MFT_ADCMP.h TEST_MFT_FRT.c TEST_MFT_FRT.h TEST_MFT_OCU.c TEST_MFT_OCU.h TEST_MFT_WFG.c TEST_MFT_WFG.h
    ./: startup_mb9bf50x.s
  group source_files/driver/mft
    ../../../../driver/mft/: mft_adcmp_fm3.c mft_adcmp_fm3.h mft_frt_fm3.c mft_frt_fm3.h mft_icu_fm3.c mft_icu_fm3.h mft_ocu_fm3.c mft_ocu_fm3.h mft_wfg_fm3.c mft_wfg_fm3.h
