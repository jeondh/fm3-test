# IAR project mb9bf506r_extint.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF506R Fujitsu MB9BF506R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\common; ..\..\..\..\driver; ..\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb9bf506r_template.srec
  ILINK.IlinkOutputFile: mb9bf506r_template.out
  ILINK.IlinkIcfFile: config\mb9bf506_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\common; ..\..\example\source
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: Readme.txt
  group common
    ../../../../common/: system_mb9bf50x.c
  group PeriLib
    ../../../../driver/extint/: extint_fm3.c
  group source_files
    ../source/: main.c
    ./: startup_mb9bf50x.s
